<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Appli\Ux_Device_Audio20_Playback_Appli.ewp</path>
  </project>
  <batchBuild />
</workspace>
